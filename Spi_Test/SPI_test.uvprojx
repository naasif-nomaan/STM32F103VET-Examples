# Keil uVision project SPI_test.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI_test (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Main.c GPIO_Config.c GPIO_Config.h
    ../../interrupt check/: delay.c delay.h
  group Lib
    ./: SPI.c SPI.h
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0
